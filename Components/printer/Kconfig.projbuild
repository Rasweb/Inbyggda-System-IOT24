## Components/printer/Kconfig.projbuild
```kconfig
menu "Printer configuration"
    config PRINT_LEVEL
        int 0
        default 0
        
endmenu
```
